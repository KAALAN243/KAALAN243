## sdkconfig.defaults
```kconfig
CONFIG_ESP32_WIFI_STATIC_RX_BUF_NUM=10
CONFIG_ESP32_WIFI_DYNAMIC_RX_BUF_NUM=32
CONFIG_BT_ENABLED=y
CONFIG_BTDM_CTRL_MODE_BTDM=1
```
